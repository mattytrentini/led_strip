# Repository mattytrentini/led_strip

File README.md:

# LED strip controller
Control an LED strip using an ESP8266, PWM, an N-Channel MOSFET, a rotary encoder and some Micropython

Uses SpotlightKid's [Rotary Encoder Library](https://github.com/SpotlightKid/micropython-stm-lib/tree/master/encoder). 
Just copy `encoder.py` from the above library, `ledstripcontroller.py`, and `main.py` to the ESP8266; tweak if your hardware is different!

## KiCad design shield/shield.kicad_pcb

File shield/README.md:

# LED Strip Driver WeMos D1 Mini Shield

These are the [KiCad](http://kicad-pcb.org/) design files for a Shield for the WeMos D1 Mini that can be used to drive LED strips.

This is designed to be a compact, reusable, versatile, and web-connected design to allow for quick lighting solutions, as well as other simple, relatively high current generic driving applications.

The template for the WeMos D1 Mini shield came from jerome-labidurie's [Kicad tools for Wemos D1 mini](https://github.com/jerome-labidurie/d1_mini_kicad).

Parts:
C1: 10uF; C_0805_HandSoldering
C2, C4, C5: 100nF; C_0805_HandSoldering
C3: 22uF; C_0805_HandSoldering
D1: D; D_SMB-SMC_Universal_Handsoldering
J1: Screw_Terminal_1x04; TerminalBlock_Pheonix_MPT-2.54mm_4pol
J2: Screw_Terminal_1x02; TerminalBlock_Pheonix_MPT-2.54mm_2pol
J4: Screw_Terminal_1x06; TerminalBlock_Pheonix_MPT-2.54mm_6pol
P1, P2: CONN_01X08; D1_mini_Pin_Header
Q1, Q2, Q3: Q_NMOS_GSD; SOT-23_Handsoldering
R1, R2, R3: 220R; R_0805_HandSoldering
R4, R5, R6: 27k; R_0805_HandSoldering
ROT1: ROTARY-ENCODER; SF-ROTARY-ENCODER
U1: LM1117-3.3; SOT-223

Connections:
+3V3: C3.1, J1.1, P2.1, U1.2 (VO), U1.4 (VO)
+12V: C1.1, D1.1 (K), J4.1, J4.3, J4.5, U1.3 (VI)
/+5V: P1.1
/A0: P2.7
/D0: P2.6
/D_OUT: J1.2, P2.2
/ENC_A: R4.1, ROT1.2 (A)
/ENC_B: R5.1, ROT1.4 (B)
/ENC_SWITCH: R6.2, ROT1.1 (SW1)
/LED_DRIVE_1: P2.3, R1.1
/LED_DRIVE_2: P2.4, R2.1
/LED_DRIVE_3: P2.5, R3.1
/MCU_A: C4.1, P1.6, R4.2
/MCU_B: C5.1, P1.5, R5.2
/MCU_SWITCH: C2.1, P1.3, R6.1
/PIR_IN: J1.3, P1.4
/RST: P2.8
/RX: P1.7
/TX: P1.8
GND: C1.2, C2.2, C3.2, C4.2, C5.2, J1.4, J2.2, P1.2, Q1.2 (S), Q2.2 (S), Q3.2 (S), ROT1.3 (C), ROT1.5 (SW2), U1.1 (GND/ADJ)
unnamed: D1.2 (A), J2.1
unnamed: J4.2, Q1.3 (D)
unnamed: J4.4, Q2.3 (D)
unnamed: J4.6, Q3.3 (D)
unnamed: Q1.1 (G), R1.2
unnamed: Q2.1 (G), R2.2
unnamed: Q3.1 (G), R3.2

Notes on the sheet:
GPIO2
GPIO0
GPIO4
GPIO5
GPIO15
GPIO13
GPIO12
GPIO14
GPIO16
WeMos D1 Mini connections
12V in
LED string outputs
General I/O
Rotary encoder with switch
3V3 regulator

Board: 2 copper layers, 25.7 x 34.4 mm, 22 parts (20 on the bottom side), 21 nets.

File shield/shield_BOM.xlsx:

Id;"Designator";"Package";"Quantity";"Designation";"Supplier and ref";
1;"J1";"TerminalBlock_Pheonix_MPT-2.54mm_4pol";1;"Screw_Terminal_1x04";;;
2;"U1";"SOT-223";1;"LM1117-3.3";;;
3;"P1, P2";"D1_mini_Pin_Header";2;"CONN_01X08";;;
4;"";"OSHW";1;"OSHW";;;
5;"C1";"C_0805_HandSoldering";1;"10uF";;;
6;"C2, C4, C5";"C_0805_HandSoldering";3;"100nF";;;
7;"C3";"C_0805_HandSoldering";1;"22uF";;;
8;"J2";"TerminalBlock_Pheonix_MPT-2.54mm_2pol";1;"Screw_Terminal_1x02";;;
9;"J4";"TerminalBlock_Pheonix_MPT-2.54mm_6pol";1;"Screw_Terminal_1x06";;;
10;"R1, R2, R3";"R_0805_HandSoldering";3;"220R";;;
11;"R4, R5, R6";"R_0805_HandSoldering";3;"27k";;;
12;"Q3, Q2, Q1";"SOT-23_Handsoldering";3;"Q_NMOS_GSD";;;
13;"ROT1";"SF-ROTARY-ENCODER";1;"ROTARY-ENCODER";;;
14;"D1";"D_SMB-SMC_Universal_Handsoldering";1;"D";;;
Id | Designator | Quantity | Designation | Manufacturer | Manufacturer PN | Supplier | Supplier PN | Cost (AUD, ea) | Cost (total) | Package
1 | J1 | 1 | Screw_Terminal_1x04 | On Shore Technology Inc. | OSTVN04A150 | Digi-Key | ED10563-ND | 1.81 | 1.81 | TerminalBlock_Pheonix_MPT-2.54mm_4pol
2 | U1 | 1 | LM1117-3.3 | Texas Instruments | LM1117MPX-3.3/NOPB | Digi-Key | LM1117MPX-3.3/NOPBCT-ND | 1.36 | 1.36 | SOT-223
3 | P1, P2 | 2 | CONN_01X08 | Sullins Connector Solutions | PREC008SAAN-RC | Digi-Key | S1012EC-08-ND | 0.26 | 0.52 | D1_mini_Pin_Header
4 |  | 1 | OSHW | Sullins Connector Solutions |  | Digi-Key |  |  | 0 | OSHW
5 | C1 | 1 | 10uF | Taiyo Yuden | TMK212BBJ106KG-T | Digi-Key | 587-2985-1-ND | 0.25 | 0.25 | C_0805_HandSoldering
6 | C2, C4, C5 | 3 | 100nF | KEMET | C0805C104K5RACTU | Digi-Key | 399-1170-1-ND | 0.13 | 0.39 | C_0805_HandSoldering
7 | C3 | 1 | 22uF | Samsung Electro-Mechanics America, Inc. | CL21A226MQQNNNG | Digi-Key | 1276-6460-1-ND | 0.21 | 0.21 | C_0805_HandSoldering
8 | J2 | 1 | Screw_Terminal_1x02 | On Shore Technology Inc. | OSTVN02A150 | Digi-Key | ED10561-ND | 1.19 | 1.19 | TerminalBlock_Pheonix_MPT-2.54mm_2pol
9 | J4 | 1 | Screw_Terminal_1x06 | On Shore Technology Inc. | OSTVN06A150 | Digi-Key | ED10565-ND | 2.3199999999999998 | 2.3199999999999998 | TerminalBlock_Pheonix_MPT-2.54mm_6pol
10 | R1, R2, R3 | 3 | 220R | Yageo | RC0805FR-07220RL | Digi-Key | 311-220CRCT-ND | 0.13 | 0.39 | R_0805_HandSoldering
11 | R4, R5, R6 | 3 | 27k | Yageo | RC0805FR-0727KL | Digi-Key | 311-27.0KCRCT-ND | 0.13 | 0.39 | R_0805_HandSoldering
12 | Q3, Q2, Q1 | 3 | Q_NMOS_GSD | Diodes Incorporated | DMN3404L-7 | Digi-Key | DMN3404LDICT-ND | 0.59 | 1.77 | SOT-23_Handsoldering
13 | ROT1 | 1 | ROTARY-ENCODER | TT Electronics/BI | EN12-HS11AF25 | Digi-Key | 987-1194-ND | 1.4 | 1.4 | SF-ROTARY-ENCODER
14 | D1 | 1 | D | Diodes Incorporated | B540C-13-F | Digi-Key | B540C-FDICT-ND | 0.72 | 0.72 | D_SMB-SMC_Universal_Handsoldering
 |  |  |  |  |  |  |  | BOM cost (AUD): | 12.720000000000002

## Commit log

2017-05-28 Updated README.md to link to the SpotlightKid's Rotary Encoder library and tidied up the Fritzing breadboard view.
2017-05-29 Very hacky workaround to ignore the rotary encoder except when LED's are fully on (ie not off or fading).
    Can definitely reduce the number of variables...
2017-05-29 Tidied up the on/off logic
2017-05-29 Modified fade to allow the duration to be specified rather than the sleep interval. Now fades are all the same duration regardless of brightness.
2017-06-05 Initial commit of KiCad design files for a WeMos D1 Mini Shield that implements the LED Strip driving concept in a more compact, reliable, and repeatable fashion.
    Changes:
    * shield/*
    * Added KiCad design files
    * Added README.md giving brief description of intent and tools used
    * .gitignore
    * Added KiCad targeted ignores
2017-06-06 Modified the shield design to utilise a 3V3 LDO instead of 5V regulator module. Powering the Wemos D1 Mini through it's 3V3 pin instead of 5V (effectively bypassing the onboard regulator).
2017-06-06 Schematic changes as per merge request discussion, and beginning PCB layout
    Changes:
    * Schematic
    * Changed rotary encoder schematic part
    * Added debounce circuitry to all rotary encoder signal lines
    * Changed rotary encoder pinout to match existing circuitry
    * Changed MOSFETs to GSD style
2017-06-13 Updated PCB to have rotary encoder on top side of PCB and terminal blocks on bottom of PCB. PCB outline slightly adjusted to allow for large components (now overhangs the incuts on the Wemos board fo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
2017-06-16 Rotated J1 to face bottom edge, and brought J1 and J2 closer to centre of PCB
2017-08-03 Routed PCB, and added a filled-out BOM (Digi-Key source)
2017-08-07 Updated PCB to 2 layers - WIP
2017-08-07 Finished updating PCB to 2 layers
2017-08-13 Updated to use asyncio. Gideon contributed most of this effort! It needs to be tidied up but it's a great start.
2017-09-27 Tidy up Disable changing encoder value when in switched off state Wrap in a class
2018-01-27 Multiple changes in line with making the shield PCB work
    * LedStripController class brought out into it's own file
    * main.py simplified
    * main_shield.py created for initialisation of shield PCB
    * In the LedStripController class:
    ** Extra check added for more robust debouncing
    ** Added prints for debugging
2018-02-27 Merging Olivers improvements
2018-02-27 Update README.md
    Replaced `main.py` with `main_shield.py` and removed `main_shield.py`. Updated README to match.
2018-02-28 Removed references to machine.Pin and machine.PWM from inside ledstripcontroller. Changed to use the millisec version of async.sleep.
2018-03-05 Only update the duty when there's a change in step. Stops flickering.
2018-03-06 Added the most basic of Makefiles to deploy the files to an ESP device over serial using mpfshell.
2018-03-07 Adding some diagnostics to determine why fading isn't as smooth as it should be.
2018-03-11 Added a crude debug log that prints in an async function service every 500ms. Prevents interference in timing-sensitive loops.
2018-03-11 Removed the unnecessary encoder. LedStripController owns an encoder now...
2018-03-12 Tidied up debug output. Then removed it as it does interrupt the fading while printing to serial!
2018-04-24 Multiple changes
    * Set default brightness to half-on
    * Defaults to off
    * Set pins to work with the ESP32 TTGO board
    * Moved event loop to main
2018-04-28 Generalising initialisation to depend on the type of board detected
    Now allows for either the Wemos D1 Mini series or the TTGO boards to be used
2018-04-28 Ensuring LED drivers default to not being driven - refs #18
2018-04-28 Refactoring to bring button code out of LedStripController and implementing PIR
2018-04-28 Combining irq handlers into one (as required by Micropython)
